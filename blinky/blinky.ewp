# IAR project blinky.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..; D:\sherif hammad\work_starting_Jan_2018\CSE316-318_FAll_18\IAR_Projects\lesson x - lec7 - Step 5 - TivaWare_C_Series-2.1.4.178 - Path; C:\Users\moham\Desktop\ASU Docs\Microcontrollers\Assignment\lec 8 - Step 2 - systick - Blinky - TivaWare
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: blinky.bin
  ILINK.IlinkOutputFile: blinky.out
  ILINK.IlinkIcfFile: blinky.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ./: blinky.c startup_ewarm.c
